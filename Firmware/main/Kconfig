## Firmware/main/Kconfig
```kconfig
config WIFI_SSID
  string "Wi-Fi SSID"
  default ""

config WIFI_PASSWORD
  string "Wi-Fi Password"
  default ""
```
